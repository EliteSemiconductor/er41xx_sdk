# Keil uVision project 802154TxRx_Addressing.uvprojx, settings and files
target 802154TxRx_Addressing (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: NANO100KE3BN Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.3
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(42000000) CPUTYPE("Cortex-M0")
  output: 802154TxRx_Addressing +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: PLATFORM_NANO100
  c include: ..\..\Nano100Lib\CMSIS\Include;..\..\Nano100Lib\Device\Nuvoton\Nano100Series\Include;..\..\Nano100Lib\StdDriver\inc;..\Common;..\RF Drivers;..\RF Drivers\ER4100Api
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_Nano100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Nano100Lib/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
    ../../Nano100Lib/Device/Nuvoton/Nano100Series/Source/ARM/: startup_Nano100Series.s
  group NanoLibraries
    ../../Nano100Lib/StdDriver/src/: clk.c sys.c uart.c gpio.c spi.c retarget.c
  group Common
    ../Common/: Common.h Delay.c Delay.h AppUart.c AppUart.h
  group User
    ../User/: main.c
  group RF Drivers
    ../RF Drivers/: RF_Hal.c RF_Hal.h RF_App.c RF_App.h
    ../RF Drivers/ER4100Api/: SPI_ER41xx.c SPI_ER41xx.h SPI_ER41xx_config.h compiler_compat.h
software components: CMSIS:CORE 6.1.0
