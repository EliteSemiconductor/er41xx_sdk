# Keil uVision project TransTxRx_CCIT_PER.uvproj, settings and files
target N76E003_8051 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: ER4100_TransTxRx_CCIT_PER +hex
  c flags: Optimize=8
  c define: FOSC_160000
  c include: ..\Include;..\Common;..\Project;.\Source;..\RF Drivers;..\RF Drivers\XtApp;..\RF Drivers\\Er4100Api;..\RF Drivers\XtUser;..\User;..\Include\MCU
  link misc: REMOVEUNUSED
  group Startup
    ./: STARTUP.A51
  group Include
    ../Include/: Function_Define.h N76E003.h SFR_Macro.h
  group Common
    ../Common/: Common.h Delay.c Uart.c
  group User
    ../User/: main.c
  group RF Drivers
    ../RF Drivers/: RF_App.c RF_App.h RF_Hal.c RF_Hal.h
    ../RF Drivers/ER4100Api/: SPI_ER41xx.c SPI_ER41xx.h SPI_ER41xx_config.h
